# Keil uVision project MKL LoRaWAN GW v1.1.uvprojx, settings and files
target MKL LoRaWAN GW v1.1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MKL16Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.12.0
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MKL LoRaWAN GW v1.1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Apps;..\Boards\Device;..\Boards\MCU;..\Mac;..\Peripherals;..\Radio;..\System;..\System\crypto;..\Debug
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group Apps
    ../Apps/: main.c
  group Boards/Device
    ../Boards/Device/: board.c
  group Boards/MCU
    ../Boards/MCU/: buff.c csma.c utilities.c
  group Debug
    ../Debug/: debug.c
  group Mac
    ../Mac/: LoRaMac_QH.c LoRaMacCrypto.c
  group Peripherals
    ../Peripherals/: mkl_si7020.c opt3001.c gpio_board.c
  group Radio
    ../Radio/: sx1276_QH.c
  group System
    ../System/: driver_common.c flash.c gpio.c i2c.c spi_gpio.c timer.c uart.c
  group System/Crypto
    ../System/crypto/: aes.c cmac.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
